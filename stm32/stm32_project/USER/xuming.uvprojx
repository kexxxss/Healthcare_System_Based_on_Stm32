# Keil uVision project xuming.uvprojx, settings and files
target xuming (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: xuming +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\IIC;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\KEY;..\NET\device;..\NET\MQTT;..\NET\onenet;..\SYSTEM\timer;..\HARDWARE\AS608;..\HARDWARE\IIC2;..\NET\cJSON
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/timer/: timer.c
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/IIC/: algorithm.c max30102.c myiic.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/IIC2/: IIC2.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group NET
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
    ../NET/cJSON/: cJSON.c
